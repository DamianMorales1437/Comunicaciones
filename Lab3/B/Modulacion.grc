options:
  parameters:
    author: Damian_Morales_J1C_G6
    copyright: UIS
    generate_options: qt_gui
    id: Modulacion
    output_language: python
    title: Modulacion
  states: {}

blocks:
- name: Ac
  id: variable_qtgui_range
  parameters:
    label: Amplitud portadora
    start: '0'
    step: '1e-3'
    stop: '1'
    value: '125e-3'
  states: {}
- name: Am
  id: variable_qtgui_range
  parameters:
    label: Amplitud mensaje
    start: '0'
    step: '100e-3'
    stop: '4'
    value: '1'
  states: {}
- name: B
  id: variable_qtgui_range
  parameters:
    label: Cambio de bandas laterales (B)
    start: '-1'
    step: '2'
    stop: '1'
    value: '1'
  states: {}
- name: GTX
  id: variable_qtgui_range
  parameters:
    label: Ganancia de transmisor
    start: '0'
    step: '1'
    stop: '30'
    value: '0'
  states: {}
- name: K
  id: variable_qtgui_range
  parameters:
    label: Habilitar portadora K
    start: '0'
    step: '1'
    stop: '1'
    value: '1'
  states: {}
- name: audio_rate
  id: variable
  parameters:
    value: '44100'
  states: {}
- name: fc
  id: variable_qtgui_range
  parameters:
    label: Frecuencia de Portadora
    start: 50e6
    step: 1e6
    stop: 2.2e9
    value: 50e6
  states: {}
- name: fm
  id: variable_qtgui_range
  parameters:
    label: frecuencia mensaje
    start: '300'
    step: '100'
    stop: '21000'
    value: '1000'
  states: {}
- name: ka
  id: variable_qtgui_range
  parameters:
    label: coeficiente (Ka)
    start: '0'
    step: '0.1'
    stop: '4'
    value: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 12500000/64
  states: {}
- name: Lab3_a_0
  id: Lab3_a
  parameters:
    l_vect: '1024'
  states: {}
- name: ModuladorAMSSB_0
  id: ModuladorAMSSB
  parameters:
    Ac: Ac
    B: K
    K: B
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: samp_rate
    fc: '0'
    fftsize: '32768'
    name: '"Ganancia Relativa"'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: fc
    gain0: GTX
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [ModuladorAMSSB_0, '0', qtgui_freq_sink_x_0, '0']
- [ModuladorAMSSB_0, '0', qtgui_time_sink_x_0, '0']
- [ModuladorAMSSB_0, '0', uhd_usrp_sink_0, '0']
- [analog_sig_source_x_0, '0', Lab3_a_0, '0']
- [analog_sig_source_x_0, '0', ModuladorAMSSB_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
